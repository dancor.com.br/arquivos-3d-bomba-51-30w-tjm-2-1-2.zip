Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: W:\PRODUTOS\ALTOQI\IFCs . STP\BOMBA 51-30W TJM 2.1-2'' 7,5CV T 220-380V INC IR3.IFC
Time: 2026-06-08T18:12:37+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
